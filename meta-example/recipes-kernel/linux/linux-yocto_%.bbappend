FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://hello.patch"
SRC_URI += " file://0001-Patch-esame.patch"
